# IAR project MPUDemo.ewp, settings and files
configuration MPUDemo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCIncludePath2: ../../ST_Code/Core/Inc; ../../ST_Code/Drivers/STM32L4xx_HAL_Driver/Inc; ../../ST_Code/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../ST_Code/Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../ST_Code/Drivers/CMSIS/Include; ../../Config; ../../Demo; ../../../../Source/include; ../../../../Source/portable/IAR/ARM_CM4F_MPU; ../../../../Source/portable/IAR/ARM_CM4F_MPU
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Config; ..\..\..\..\Source\include
  OBJCOPY.OOCOutputFile: MPUDemo.hex
  ILINK.IlinkOutputFile: MPUDemo.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Config
    ../../Config/: FreeRTOSConfig.h
  group Demo
    ../../Demo/: app_main.c app_main.h mpu_demo.c mpu_demo.h
  group FreeRTOS
    ../../../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Source/portable/MemMang/: heap_4.c
    ../../../../Source/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
    ../../../../Source/portable/IAR/ARM_CM4F_MPU/: mpu_wrappers_v2_asm.S port.c portasm.s portmacro.h
  group ST_Code/Core
    ../../ST_Code/Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c system_stm32l4xx.c
  group ST_Code/STM32L4xx_HAL_Driver
    ../../ST_Code/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Startup
    ./: memfault_handler.s startup_stm32l475xx.s
