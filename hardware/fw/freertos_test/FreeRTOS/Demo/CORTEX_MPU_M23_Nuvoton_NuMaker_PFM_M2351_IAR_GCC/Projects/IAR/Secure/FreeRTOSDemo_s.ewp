# IAR project FreeRTOSDemo_s.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..; ..\Config; ..\..\..\..\..\Source\portable\IAR\ARM_CM23\secure; ..\..\..\Nuvoton_Code\StdDriver\inc; ..\..\..\Nuvoton_Code\CMSIS\Include; ..\..\..\Nuvoton_Code\Device\Nuvoton\M2351\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: configENABLE_FPU=0; configENABLE_MPU=1; configENABLE_TRUSTZONE=1
  AARM.AUserIncludes: ..\Config
  AARM.AExtraOptionsV2: --cmse
  OBJCOPY.OOCOutputFile: FreeRTOSDemo_s.bin
  ILINK.IlinkOutputFile: FreeRTOSDemo_s.out
  ILINK.IlinkIcfFile: FreeRTOSDemo_s.icf
  ILINK.IlinkExtraOptions: --import_cmse_lib_out=Objects\FreeRTOSDemo_s_importlib.o
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Device
    ../: partition_M2351.h
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Drivers
    ../../../Nuvoton_Code/StdDriver/src/: clk.c gpio.c retarget.c
  group NSCFunctions
    ../../../../Common/ARMv8M/tz_demo/: nsc_functions.c nsc_functions.h
    ../../../../Common/ARMv8M/reg_tests/IAR/ARM_CM23/secure/: secure_reg_test.c secure_reg_test_asm.h secure_reg_test_asm.s
  group SecureContext
    ../../../../../Source/portable/IAR/ARM_CM23/secure/: secure_context.c secure_context.h secure_context_port_asm.s secure_port_macros.h
  group SecureHeap
    ../../../../../Source/portable/IAR/ARM_CM23/secure/: secure_heap.c secure_heap.h
  group SecureInit
    ../../../../../Source/portable/IAR/ARM_CM23/secure/: secure_init.c secure_init.h
  group User
    ./: main_s.c
