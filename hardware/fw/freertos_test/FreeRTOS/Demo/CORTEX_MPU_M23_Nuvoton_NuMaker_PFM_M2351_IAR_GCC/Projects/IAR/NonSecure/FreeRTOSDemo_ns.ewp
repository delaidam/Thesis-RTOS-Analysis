# IAR project FreeRTOSDemo_ns.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_PORT=UART0_NS
  ICCARM.CCIncludePath2: ..\Config; ..\..\..\..\Common\ARMv8M\mpu_demo; ..\..\..\..\Common\ARMv8M\tz_demo; ..\..\..\..\..\Source\include; ..\..\..\..\..\Source\portable\IAR\ARM_CM23\secure; ..\..\..\..\..\Source\portable\IAR\ARM_CM23\non_secure; ..\..\..\Nuvoton_Code\StdDriver\inc; ..\..\..\Nuvoton_Code\CMSIS\Include; ..\..\..\Nuvoton_Code\Device\Nuvoton\M2351\Include; ..\..\..\..\Common\ARMv8M\reg_tests\IAR\ARM_CM23\secure; ..\..\..\..\Common\ARMv8M\reg_tests\IAR\ARM_CM23\non_secure; ..\..\..\RegTests
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: configENABLE_FPU=0; configENABLE_MPU=1; configENABLE_TRUSTZONE=1
  AARM.AUserIncludes: ..\Config; ..\..\..\..\..\Source\include
  OBJCOPY.OOCOutputFile: FreeRTOSDemo_ns.bin
  ILINK.IlinkOutputFile: FreeRTOSDemo_ns.out
  ILINK.IlinkIcfFile: FreeRTOSDemo_ns.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Config
    ../Config/: FreeRTOSConfig.h
  group Demos
    ../../../../Common/ARMv8M/mpu_demo/: mpu_demo.c mpu_demo.h
    ../../../../Common/ARMv8M/reg_tests/IAR/ARM_CM23/non_secure/: reg_test_asm.h reg_test_asm.s
    ../../../RegTests/: reg_tests.c reg_tests.h
    ../../../../Common/ARMv8M/tz_demo/: tz_demo.c tz_demo.h
  group Device
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Drivers
    ../Secure/Objects/: FreeRTOSDemo_s_importlib.o
    ../../../Nuvoton_Code/StdDriver/src/: gpio.c retarget.c
  group FreeRTOS
    ../../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Source/portable/MemMang/: heap_4.c
    ../../../../../Source/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
    ../../../../../Source/portable/IAR/ARM_CM23/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h
  group User
    ./: fault_handler.s main_ns.c
